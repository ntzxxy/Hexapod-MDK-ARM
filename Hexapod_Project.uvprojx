# Keil uVision project Hexapod_Project.uvprojx, settings and files
target Hexapod_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Hexapod_Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;./USER/TASK;./USER/APP;./USER/DMP;./USER/ST7735
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group TASK
    ./USER/TASK/: LegControl_task.cpp MPU_task.cpp LCD_task.cpp Key_task.cpp
  group APP
    ./USER/APP/: dwt_delay_us.c leg.cpp Servo.cpp my_math.cpp gait_prg.cpp debug_uart.c key.cpp remote.c mpu6050.cpp auto_control.c
  group DMP
    ./USER/DMP/: dmp_interface.c inv_mpu.c inv_mpu_dmp_motion_driver.c
  group ST7735
    ./USER/ST7735/: lcd.c st7735.c st7735_reg.c
software components: CMSIS:CORE 4.3.0
